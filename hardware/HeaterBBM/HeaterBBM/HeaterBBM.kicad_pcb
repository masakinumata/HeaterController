# Repository masakinumata/HeaterController

## KiCad design hardware/HeaterBBM/HeaterBBM/HeaterBBM.kicad_pcb

Parts:
B101: Board_1U_60x60
C101, C102, C103: 10uF; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal; LCSC C19702
F101: Polyfuse; C_Disc_D5.1mm_W3.2mm_P5.00mm
J101: THR1; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J102: HeaterLiPo; JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical
J103: THR2; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J104: INA226; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J105: INA226_IF; PinSocket_1x05_P2.54mm_Vertical
J106: THR3; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J107: Heater; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J108: MainBattery; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J109: TPS63802_IN; PinSocket_1x05_P2.54mm_Vertical
J110: TPS63802_OUT; PinSocket_1x05_P2.54mm_Vertical
J111: AE-MICRO-SD-DIP; PinSocket_1x10_P2.54mm_Vertical
J112: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
LED101: Heater; LED_D3.0mm_FlatTop; LCSC C2296
Q101: NMOS; TSOT-23_HandSoldering
R101, R105, R107: 120; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal; LCSC C25079
R102, R106, R108, R110: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal; LCSC C25744
R103, R104, R112, R113, R114, R115, R116: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R109: 510; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal; LCSC C25123
R111: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal; LCSC C25123
U101: ESP32S3 Devkit; ESP32S3_devkit

Connections:
+5V: J112.2, U101.21 (5V)
/CH1: R101.1, U101.4 (IO4)
/CH2: R105.1, U101.5 (IO5)
/CH3: R107.1, U101.6 (IO6)
/CS: J111.2, R113.2, U101.19 (IO13)
/DAT1: J111.8, R116.2
/DAT2: J111.1, R112.2
/Heater: LED101.2 (A), R109.2, U101.9 (IO16)
/I2C_SCL: J105.2, R104.2, U101.11 (IO18)
/I2C_SDA: J105.3, R103.2, U101.10 (IO17)
/MISO: J111.7, R115.2, U101.16 (IO10)
/MOSI: J111.3, R114.2, U101.18 (IO12)
/SCK: J111.5, U101.17 (IO11)
/SWA: J111.10
/SWB: J111.9
/Sence+: F101.2, J104.1, J104.2
/Sence-: J104.3, J107.1
/Vbat: J108.1 (Pin_2), J109.1, J109.2
GND: B101.GND, C101.2, C102.2, C103.2, J102.1, J104.4, J105.5, J108.2 (Pin_1), J109.4, J109.5, J110.1, J110.2, J111.6, Q101.3 (S), R102.2, R106.2, R108.2, R110.2, R111.2, U101.22 (GND), U101.23 (GND), U101.24 (GND), U101.44 (GND)
unnamed: C101.1, J101.2, R101.2, R102.1
unnamed: F101.1, J102.2
unnamed: C102.1, J103.2, R105.2, R106.1
unnamed: C103.1, J106.2, R107.2, R108.1
unnamed: J107.2, Q101.1 (D)
unnamed: J110.4, J110.5, J112.3
unnamed: LED101.1 (K), R111.1
unnamed: Q101.2 (G), R109.1, R110.1
VDD: J101.1, J103.1, J105.1, J106.1, J111.4, J112.4, R103.1, R104.1, R112.1, R113.1, R114.1, R115.1, R116.1, U101.1 (3V3), U101.2 (3V3)

Notes on the sheet:
2S 7.4V
Heater
定格:1.35A trip:2.7A
1.8V~5.5V

Board: 2 copper layers, 84.3 x 60.0 mm, 36 parts (0 on the bottom side), 26 nets.

File hardware/HeaterBBM/HeaterBBM/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
B101,Board_1U_60x60,1,~,
"C101, C102, C103",C_Disc_D5.1mm_W3.2mm_P5.00mm,3,10uF,C19702
F101,C_Disc_D5.1mm_W3.2mm_P5.00mm,1,Polyfuse,
J101,JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,1,THR1,
J102,JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical,1,HeaterLiPo,
J103,JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,1,THR2,
J104,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,INA226,
J105,PinSocket_1x05_P2.54mm_Vertical,1,INA226_IF,
J106,JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,1,THR3,
J107,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,1,Heater,
J108,JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,1,MainBattery,
J109,PinSocket_1x05_P2.54mm_Vertical,1,TPS63802_IN,
J110,PinSocket_1x05_P2.54mm_Vertical,1,TPS63802_OUT,
J111,PinSocket_1x10_P2.54mm_Vertical,1,AE-MICRO-SD-DIP,
J112,PinHeader_1x04_P2.54mm_Vertical,1,Conn_01x04,
LED101,LED_D3.0mm_FlatTop,1,Heater,C2296
Q101,TSOT-23_HandSoldering,1,NMOS,
"R101, R105, R107",R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal,3,120,C25079
"R102, R106, R108, R110",R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal,4,10k,C25744
"R103, R104, R112, R113, R114, R115, R116",R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal,7,10k,
R109,R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal,1,510,C25123
R111,R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal,1,1k,C25123
U101,ESP32S3_devkit,1,ESP32S3 Devkit,

## KiCad design hardware/heater-controller/heater-controller.kicad_pcb

Parts:
A101: RaspberryPi_Pico; RaspberryPi_Pico_Common_Unspecified
D101: D_Schottky; D_SOD-123
D102: power; LED_0805_2012Metric
J101: pico LiPo; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
R101: 1k; R_0805_2012Metric
SW101: power; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm

Connections:
/Heater/SCL: A101.22 (GPIO17); also elsewhere on the board
/Heater/SDA: A101.21 (GPIO16); also elsewhere on the board
/Heater/bat_heater: A101.31 (GPIO26_ADC0); also elsewhere on the board
/Heater/heater_con: A101.24 (GPIO18); also elsewhere on the board
/Thermistor1/AGND: A101.33 (AGND); also elsewhere on the board
/Thermistor1/R_Thermistor1: A101.32 (GPIO27_ADC1); also elsewhere on the board
/Thermistor1/R_Thermistor2: A101.34 (GPIO28_ADC2); also elsewhere on the board
GND: A101.3 (GND), A101.8 (GND), A101.13 (GND), A101.18 (GND), A101.23 (GND), A101.28 (GND), A101.38 (GND), D102.1 (K), J101.2; also elsewhere on the board
unnamed: A101.39 (VSYS), D101.1 (K)
unnamed: D101.2 (A), R101.2, SW101.1 (A)
unnamed: D102.2 (A), R101.1
unnamed: J101.1, SW101.2 (B)
VDD: A101.36 (3V3); also elsewhere on the board

Parts:
C301, C302: 0.1u; C_0805_2012Metric
J301: Thermistor1; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J302: Thermistor2; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
R301, R302: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal

Connections:
/Thermistor1/AGND: C301.1, C302.1, R301.2, R302.2; also elsewhere on the board
/Thermistor1/R_Thermistor1: C301.2, J301.2, R301.1; also elsewhere on the board
/Thermistor1/R_Thermistor2: C302.2, J302.2, R302.1; also elsewhere on the board
VDD: J301.1, J302.1; also elsewhere on the board

Parts:
C201: 10u; C_1206_3216Metric
C202: 0.1u; C_0805_2012Metric
C203: 10uF; C_1206_3216Metric
C204: 100nF; C_0805_2012Metric
D201: H_BATT; LED_0805_2012Metric
D202: Heater; LED_0805_2012Metric
D203: D_Schottky; D_SOD-123
J201: heater LiPo; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J202: heater; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
J203: heater_SW_EX; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
Q201: Nch; Nch mosfet TK7R4A10PL
R201, R206: 1k; R_0805_2012Metric
R202: 22k; R_0805_2012Metric
R203: 4.7k; R_0805_2012Metric
R204, R208, R209: 10k; R_0805_2012Metric
R205: 100; R_0805_2012Metric
R207: 20mΩ; R_2512_6332Metric
R210, R211: 10; R_0805_2012Metric
SW201: heater_SW; SW_slide
U201: INA226; VSSOP-10_3x3mm_P0.5mm

Connections:
/Heater/SCL: R208.1, U201.5 (SCL); also elsewhere on the board
/Heater/SDA: R209.2, U201.4 (SDA); also elsewhere on the board
/Heater/bat_heater: R202.2, R203.1; also elsewhere on the board
/Heater/heater_con: R205.2; also elsewhere on the board
GND: C201.1, C203.2, C204.2, D201.1 (K), J201.2, Q201.1 (S), Q201.2 (S), Q201.3 (S), R203.2, R204.1, U201.1 (A1), U201.2 (A0), U201.7 (GND); also elsewhere on the board
unnamed: D201.2 (A), R201.1
unnamed: D202.1 (K), R206.2
unnamed: D203.2 (A), R206.1
unnamed: D203.1 (K), J202.2, Q201.5 (D)
unnamed: C201.2, J202.1, R207.2, R210.2
unnamed: J203.2, R207.1, R211.2, SW201.1 (A)
unnamed: Q201.4 (G), R204.2, R205.1
unnamed: C202.1, R211.1, U201.8 (Vbus), U201.10 (Vin+)
unnamed: C202.2, R210.1, U201.9 (Vin-)
VDD: C203.1, C204.1, D202.2 (A), R208.2, R209.1, U201.6 (VS); also elsewhere on the board
VPP_h: J201.1, J203.1, R201.2, R202.1, SW201.2 (B)

Board: 2 copper layers, 60.0 x 60.0 mm, 36 parts (0 on the bottom side), 23 nets.

File hardware/heater-controller/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"_4, _3, _2, ",,4,,
A101,RaspberryPi_Pico_Common_Unspecified,1,RaspberryPi_Pico,
C201,1206,1,10u,C13585
"C202, C301, C302",0805,3,0.1u,C28233
C203,1206,1,10uF,C13585
C204,0805,1,100nF,C28233
"D101, D203",D_SOD-123,2,D_Schottky,C8598
D102,0805,1,power,C2297
D201,0805,1,H_BATT,C84256
D202,0805,1,Heater,C2296
J101,JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,1,pico LiPo,
J201,JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical,1,heater LiPo,
J202,JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical,1,heater,
J203,JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,1,heater_SW_EX,
J301,JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,1,THR1,
J302,JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,1,THR2,
Q201,Nch mosfet TK7R4A10PL,1,Nch,
R101,0805,1,1k,C17513
"R201, R206",0805,2,1k,
R202,0805,1,22k,C17560
R203,0805,1,4.7k,C17673
"R204, R208, R209",0805,3,10k,C17414
R205,0805,1,100,C17408
R207,2512,1,20mΩ,C105360
"R210, R211",0805,2,10,C17415
"R301, R302",R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal,2,100k,
SW101,SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm,1,power,
SW201,SW_slide,1,heater_SW,
U201,VSSOP-10_3x3mm_P0.5mm,1,INA226,C49851

## Commit log

2026-01-17 Initial plan
2026-01-17 Create docs, hardware, and src directories
2026-01-17 kicadファイル作成
2026-01-18 回路図，PCB更新
2026-01-19 kicad編集
2026-01-22 BBMで問題がなければ発注可能
2026-02-07 いろいろ
2026-06-18 一旦完成
